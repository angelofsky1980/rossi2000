DESCRIPTION = "rossi2000 Tasks"
PR = "r0"

inherit task

DEPENDS = "\
  enigma2-plugin-skins-rossi2000-dbuk-hd \ 
  enigma2-plugin-systemplugins-rossi2000-bouquetupdater \
  enigma2-plugin-systemplugins-rossi2000-cronmanager \
  enigma2-plugin-systemplugins-rossi2000-graphmultiepg \
  enigma2-plugin-systemplugins-rossi2000-openvpn \
  enigma2-plugin-systemplugins-rossi2000-piconupdater \
  enigma2-plugin-systemplugins-rossi2000-secondinfobar \
"
